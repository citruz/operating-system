## buildroot-external/package/tempio/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_TEMPIO
	bool "Home Assistant tempio"
	help
	  Install Home Assistant template helper.
```
